# IAR project bootldr128.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDiagSuppress: Pe1053
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  AAVR.ADefines: INCLUDE_FILE="iom128.h"; SPMREG=SPMCSR; __MEMSPM__; __RAMPZ__
  XLINK.XclFile: bootldr.xcl
configuration Debug (AVR, debug)
  as the first configuration, except:
  group (top)
    ./: aes.c bootldr.c crc.asm loader.c spm.asm usart0.c
