# IAR project xmodem.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm88.xcl
configuration Release (AVR)
  as the first configuration, except:
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm48.xcl
  group (top)
    ./: calcrc.c init.c purge.c receive.c recv_wait.c respond.c sendc.c timer1.c uart.c validate_packet.c xmodem.c
