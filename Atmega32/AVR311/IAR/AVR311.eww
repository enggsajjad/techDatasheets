<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\multi_slave\multi_slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\standard\standard.ewp</path>
  </project>
  <batchBuild/>
</workspace>


